## boards/shields/temper_pacino/Kconfig.shield
```kconfig
config SHIELD_TEMPER_PACINO_LEFT
	def_bool $(shields_list_contains,temper_pacino_left)
```
